# IAR project S907x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: S9070
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\code\atcmd; ..\..\..\..\code\atcmd\at_esp; ..\..\..\..\code\cmsis; ..\..\..\..\code\cmsis\inc; ..\..\..\..\code\core\hal; ..\..\..\..\code\core\wlan; ..\..\..\..\code\core\os; ..\..\..\..\code\core\os\freertos_v10.0.1\Source\include; ..\..\..\..\code\core\os\freertos_v10.0.1\Source\portable\IAR\ARM_CM4F; ..\..\..\..\code\net; ..\..\..\..\code\net\httpc; ..\..\..\..\code\net\dhcps; ..\..\..\..\code\net\ping; ..\..\..\..\code\utils; ..\..\..\..\code\system; ..\..\..\..\code\system; ..\..\..\..\code\net\mbedtls\include\; ..\..\..\..\code\net\lwip\lwip_v1.4.1\port\sci; ..\..\..\..\code\net\lwip\lwip_v1.4.1\src\include\ipv4; ..\..\..\..\code\net\lwip\lwip_v1.4.1\src\include\ipv6; ..\..\..\..\code\net\lwip\lwip_v1.4.1\src\apps\sntp; ..\..\..\..\code\net\lwip\lwip_v1.4.1\port\sci\freertos; ..\..\..\..\code\net\lwip\lwip_v1.4.1\src\include; ..\..\..\..\code\net\lwip\lwip_v1.4.1\src\include\posix; ..\..\..\..\code\net\lwip\lwip_v2.0.3\port\sci; ..\..\..\..\code\net\lwip\lwip_v2.0.3\src\include; ..\..\..\..\code\net\lwip\lwip_v2.0.3\src\include\lwip; ..\..\..\..\code\net\lwip\lwip_v2.0.3\src\apps\sntp; ..\..\..\..\code\net\lwip\lwip_v2.0.3\port\sci\freertos; ..\..\..\..\code\atcmd\at_test; ..\..\..\..\code\coustom\tuya_iot\tuya_app\tuya_api\tuya_adapter_include\storage; ..\..\..\..\code\coustom\tuya_iot\tuya_app\tuya_api\tuya_adapter_include\system; ..\..\..\..\code\coustom\tuya_iot\tuya_app\tuya_api\tuya_adapter_include\wifi_intf; ..\..\..\..\code\coustom\tuya_iot\tuya_app\user\tuya_common\include; ..\..\..\..\code\coustom\tuya_iot\tuya_app\user\tuya_common\include\driver; ..\..\..\..\code\coustom\tuya_iot\tuya_app\user\tuya_user\s9070_common_config\include; ..\..\..\..\code\coustom\tuya_iot\include; ..\..\..\..\code\coustom\tuya_iot\include\common; ..\..\..\..\code\coustom\tuya_iot\include\tuya_base\kv_storge; ..\..\..\..\code\coustom\tuya_iot\include\tuya_base\kv_storge\file; ..\..\..\..\code\coustom\tuya_iot\include\tuya_base\kv_storge\flash; ..\..\..\..\code\coustom\tuya_iot\include\tuya_base\uf_file\flash; ..\..\..\..\code\coustom\tuya_iot\include\tuya_base\uf_file; ..\..\..\..\code\coustom\tuya_iot\include\tuya_middleware\httpc; ..\..\..\..\code\coustom\tuya_iot\include\tuya_middleware\mqtt; ..\..\..\..\code\coustom\tuya_iot\include\tuya_adapter\system; ..\..\..\..\code\coustom\tuya_iot\include\tuya_adapter\utilities; ..\..\..\..\code\coustom\tuya_iot\include\tuya_iot_sdk\wifi_sdk; ..\..\..\..\code\coustom\tuya_iot\include\tuya_iot_sdk\tuya_cloud; ..\..\..\..\code\coustom\tuya_iot\include\tuya_iot_sdk\com_sdk; ..\..\..\..\code\coustom\tuya_iot\include\tuya_adapter\storage; ..\..\..\..\code\coustom\tuya_iot\include\tuya_iot_sdk\wifi_cfg_serv; ..\..\..\..\code\coustom\tuya_iot\include\tuya_base\sys_serv; ..\..\..\..\code\coustom\tuya_iot\include\tuya_adapter; ..\..\..\..\code\coustom\tuya_iot\include\tuya_middleware\tls; ..\..\..\..\code\net\mqtt\MQTTPacket\src; ..\..\..\..\code\net\mqtt\MQTTPacket\samples; ..\..\..\..\code\customer; ..\..\..\..\code\customer\driver\s907x_for_zg_cfg; ..\..\..\..\code\customer\net
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\code\core\os; ..\..\..\..\code\core\os\freertos_v10.0.1\Source\include; ..\..\..\..\code\core\os\freertos_v10.0.1\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: S907x.bin
  postbuild: CSCRIPT  "..\..\..\..\script\links\IAR\s9070_build.vbs"  "..\..\..\..\out\IAR\Debug"  "..\..\..\..\out\IAR"
  ILINK.IlinkOutputFile: application.axf
  ILINK.IlinkIcfFile: ..\..\..\..\script\links\IAR\image.icf
  ILINK.IlinkProgramEntryLabel: system_ll_reset
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../script/links/IAR/: image.icf
  group at
    ../../../../code/atcmd/: at_cmd.c
  group at/at_esp
    ../../../../code/atcmd/at_esp/: at_esp_init.c at_network.c at_wlan.c
  group at/at_test
    ../../../../code/atcmd/at_test/: adc_test.c at_test.c flash_test.c gpio_test.c i2c_test.c i2s_test.c iperf_test.c ipref_sockets.c mqtt_test.c ota_test.c ping_test.c rtc_test.c spi_test.c timer_test.c tuya_test.c uart_test.c wdg_test.c wlan_test.c
  group cmsis
    ../../../../code/cmsis/: s907x_cortex.c
  group core/hal
    ../../../../code/core/hal/: hal.h hal_adc.h hal_clk.h hal_config.h hal_def.h hal_dma.h hal_flash.h hal_gpio.h hal_i2c.h hal_i2s.h hal_interrupt.h hal_loguart.h hal_pinmux.h hal_rcc.h hal_rtc.h hal_sleep.h hal_spi.h hal_timer.h hal_uart.h hal_wdg.h
  group core/os
    ../../../../code/core/os/: freertos_callback.c
  group core/os/freertos
    ../../../../code/core/os/freertos_v10.0.1/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group core/os/freertos/mem
    ../../../../code/core/os/freertos_v10.0.1/Source/portable/MemMang/: heap_4.c
  group core/os/freertos/portable
    ../../../../code/core/os/freertos_v10.0.1/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group core/wlan
    ../../../../code/core/wlan/: wlan_api.h
  group library
    ../../../../library/IAR/: s907x_net.a s907x_platform.a
  group network/dhcpc
    ../../../../code/net/dhcpc/: dhcpc.c
  group network/dhcps
    ../../../../code/net/dhcps/: dhcps.c
  group network/httpc
    ../../../../code/net/httpc/: httpc_api.c httpc_core.c
  group network/lwip/lwip1.4.1/api
    ../../../../code/net/lwip/lwip_v1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group network/lwip/lwip1.4.1/app/http
    ../../../../code/net/lwip/lwip_v1.4.1/src/apps/httpd/: httpd.c
  group network/lwip/lwip1.4.1/app/lwipf
    ../../../../code/net/lwip/lwip_v1.4.1/src/apps/lwiperf/: sci_lwiperf.c
  group network/lwip/lwip1.4.1/app/mdns
    ../../../../code/net/lwip/lwip_v1.4.1/src/apps/mdns/: mdns.c
  group network/lwip/lwip1.4.1/app/mqtt
    ../../../../code/net/lwip/lwip_v1.4.1/src/apps/mqtt/: mqtt.c
  group network/lwip/lwip1.4.1/app/sntp
    ../../../../code/net/lwip/lwip_v1.4.1/src/apps/sntp/: sntp.c sntp_api.c sntp_time.c
  group network/lwip/lwip1.4.1/app/tffp
    ../../../../code/net/lwip/lwip_v1.4.1/src/apps/tftp/: tftp_server.c
  group network/lwip/lwip1.4.1/core
    ../../../../code/net/lwip/lwip_v1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group network/lwip/lwip1.4.1/core/ipv4
    ../../../../code/net/lwip/lwip_v1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group network/lwip/lwip1.4.1/core/ipv6
    ../../../../code/net/lwip/lwip_v1.4.1/src/core/ipv6/: icmp6.c inet6.c ip6.c ip6_addr.c
  group network/lwip/lwip1.4.1/core/snmp
    ../../../../code/net/lwip/lwip_v1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group network/lwip/lwip1.4.1/netif
    ../../../../code/net/lwip/lwip_v1.4.1/src/netif/: etharp.c slipif.c
  group network/lwip/lwip1.4.1/netif/ppp
    ../../../../code/net/lwip/lwip_v1.4.1/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c lwip_md5.c magic.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group network/lwip/lwip1.4.1/port
    ../../../../code/net/lwip/lwip_v1.4.1/port/sci/freertos/: sys_arch.c
  group network/lwip/lwip2.0.3/api
    ../../../../code/net/lwip/lwip_v2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group network/lwip/lwip2.0.3/apps
    ../../../../code/net/lwip/lwip_v2.0.3/src/apps/lwiperf/: lwiperf.c
  group network/lwip/lwip2.0.3/apps/http
    ../../../../code/net/lwip/lwip_v2.0.3/src/apps/httpd/: httpd.c
  group network/lwip/lwip2.0.3/apps/mdns
    ../../../../code/net/lwip/lwip_v2.0.3/src/apps/mdns/: mdns.c
  group network/lwip/lwip2.0.3/apps/mqtt
    ../../../../code/net/lwip/lwip_v2.0.3/src/apps/mqtt/: mqtt.c
  group network/lwip/lwip2.0.3/apps/smtp
    ../../../../code/net/lwip/lwip_v2.0.3/src/apps/smtp/: smtp.c
  group network/lwip/lwip2.0.3/apps/snmp
    ../../../../code/net/lwip/lwip_v2.0.3/src/apps/snmp/: snmp_asn1.c snmp_core.c snmp_mib2.c snmp_mib2_icmp.c snmp_mib2_interfaces.c snmp_mib2_ip.c snmp_mib2_snmp.c snmp_mib2_system.c snmp_mib2_tcp.c snmp_mib2_udp.c snmp_msg.c snmp_netconn.c snmp_pbuf_stream.c snmp_raw.c snmp_scalar.c snmp_snmpv2_framework.c snmp_snmpv2_usm.c snmp_table.c snmp_threadsync.c snmp_traps.c snmpv3.c snmpv3_mbedtls.c
  group network/lwip/lwip2.0.3/apps/sntp
    ../../../../code/net/lwip/lwip_v2.0.3/src/apps/sntp/: sntp.c sntp_api.c sntp_time.c
  group network/lwip/lwip2.0.3/apps/tftp
    ../../../../code/net/lwip/lwip_v2.0.3/src/apps/tftp/: tftp_server.c
  group network/lwip/lwip2.0.3/core
    ../../../../code/net/lwip/lwip_v2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group network/lwip/lwip2.0.3/core/ipv4
    ../../../../code/net/lwip/lwip_v2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group network/lwip/lwip2.0.3/core/ipv6
    ../../../../code/net/lwip/lwip_v2.0.3/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group network/lwip/lwip2.0.3/netif
    ../../../../code/net/lwip/lwip_v2.0.3/src/netif/: ethernet.c
  group network/lwip/lwip2.0.3/port
    ../../../../code/net/lwip/lwip_v2.0.3/port/sci/freertos/: sys_arch.c
  group network/mbedtls/mbedtls-2.14.0
    ../../../../code/net/mbedtls-2.14.0/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group network/mbedtls/mbedtls_tuya
    ../../../../code/net/mbedtls/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group network/mqtt/MQTTPacket
    ../../../../code/net/mqtt/MQTTPacket/src/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c
  group network/mqtt/MQTTtransport
    ../../../../code/net/mqtt/MQTTPacket/samples/: transport.c
  group network/ping
    ../../../../code/net/ping/: ping.c
  group scripts
    ../../../../script/links/IAR/: s9070_build.bat
  group startup
    ../../../../code/startup/: system_start.c
  group store
    ../../../../code/customer/sys/zg_flash_image/: zg_image.c
  group utils
    ../../../../code/utils/: ota_hash.c ota_md5.c utils.c
  group ZG/light
    ../../../../code/customer/light/: auto_report.c clock.c color.c IR.c Light_fun.c Remote.c
  group ZG/net
    ../../../../code/customer/net/: WIFI_config.c
  group ZG/net/s907x_wlan
    ../../../../code/customer/net/s907x_wlan/: s907x_wlan.c
  group ZG/protocol_handle
    ../../../../code/customer/protocol_handle/: proto_parser_pack.c protocol_handle.c
  group ZG/socket
    ../../../../code/customer/socket/: tcp_client.c tcp_perf.c udp_perf.c
  group ZG/sys
    ../../../../code/customer/sys/: encryption.c fota.c RTC_time.c store.c ZG_AT_CMD.c ZG_system.c
  group ZG/zg_entry
    ../../../../code/customer/zg_entry/: zg_entry.c zg_main.c
